# Keil uVision project lab_interrupts.uvprojx, settings and files
target lab_interrupts (6240000::V6.24::ARMCLANG)
  device: EFM32GG990F1024 Silicon Labs
  pack: SiliconLabs.GeckoPlatform_EFM32GG_DFP.4.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab1 +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c startup.s scheduler.c
